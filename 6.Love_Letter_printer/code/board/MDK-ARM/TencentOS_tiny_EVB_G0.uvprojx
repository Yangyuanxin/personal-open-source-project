# Keil uVision project TencentOS_tiny_EVB_G0.uvprojx, settings and files
target TencentOS_tiny_EVB_G0 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: TencentOS_tiny_EVB_G0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx,HAL_TIM_MODULE_ENABLED
  c include: ../Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ..\..\arch\arm\arm-v7m\common\include; ..\..\arch\arm\arm-v7m\cortex-m0+\armcc; ..\..\kernel\core\include; ..\..\kernel\hal\include; ..\..\osal\cmsis_os; ..\..\config; ..\..\net\at\include; ..\..\net\tencent_firmware_module_wrapper; ..\..\devices\esp8266_tencent_firmware; ..\..\components\utils\JSON\include; ..\Src\hardware\OLED; ..\Src\hardware\E53_SC1; ..\Src\hardware\MC_EH205
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c i2c.c spi.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_gpio.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group tos/arch
    ../../arch/arm/arm-v7m/cortex-m0+/armcc/: port_c.c port_s.S
    ../../arch/arm/arm-v7m/common/: tos_cpu.c
  group tos/kernel
    ../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/cmsis
    ../../osal/cmsis_os/: cmsis_os.c
  group tos/config
    ../../config/: tos_config.h
  group hal
    ../../platform/hal/st/stm32g0xx/src/: tos_hal_uart.c
  group at
    ../../net/at/src/: tos_at.c
    ../../net/tencent_firmware_module_wrapper/: tencent_firmware_module_wrapper.c
  group device
    ../../devices/esp8266_tencent_firmware/: esp8266_tencent_firmware.c
  group hardware
    ../Src/hardware/OLED/: oled.c
    ../Src/hardware/E53_SC1/: e53_sc1.c
    ../Src/hardware/MC_EH205/: mc_printf_str.c
  group example
    ../../components/utils/JSON/src/: cJSON.c
    ../Src/application/: applcation.c
software components: CMSIS:CORE 4.3.0
