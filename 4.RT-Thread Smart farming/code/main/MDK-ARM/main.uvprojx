# Keil uVision project main.uvprojx, settings and files
target main (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: main +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../Core/Inc;   ../Drivers/STM32L4xx_HAL_Driver/Inc;   ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;   ../Drivers/CMSIS/Include;   ../FATFS/Target;   ../FATFS/App;   ../Middlewares/Third_Party/FatFs/src;   ..\..\libcpu\arm\cortex-m4;   ..\..\libcpu\arm\common;   ..\..\bsp;   ..\..\components\finsh;   ..\..\include;   ..\..\include\libc;   ..\..\src;   ..\Core\Src\hardware\filesystem;   ..\Core\Src\hardware\ini_parse;   ..\Core\Src\hardware\Key;   ..\Core\Src\hardware\HTS221;   ..\Core\Src\hardware\LCD-SPI;   ..\Core\Src\hardware\BH1750-IIC;   ..\Core\Src\hardware\AT24C02-IIC;   ..\Core\Src\hardware\sht30;   ..\Core\Src\famework\lcd_driver_frame;   ..\Core\Src\logic;   ..\Core\Src\ui_handler;   ..\Core\Src\famework
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c rtc.c sdmmc.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Hardware
    ../Core/Src/hardware/Key/: key.c
    ../Core/Src/hardware/sht30/: sht30.c
    ../Core/Src/hardware/ini_parse/: iniparser.c dictionary.c
    ../Core/Src/hardware/filesystem/: filesystem.c
    ../Core/Src/hardware/LCD-SPI/: lcd_spi2_drv.c
    ../Core/Src/hardware/BH1750-IIC/: bh1750_i2c_drv.c
  group framework
    ../Core/Src/famework/: menu.c menu_ui.c
    ../Core/Src/famework/lcd_driver_frame/: lcd_device.c lcd_driver.c lcd_driver_frame.c
  group ui_handler
    ../Core/Src/ui_handler/: log_ui.c para_ui.c conf_ui.c main_ui.c datetime_ui.c recovery_ui.c password_ui.c version_info_ui.c lcd_plot_display.c password_select_ui.c
  group app_logic
    ../Core/Src/logic/: app_init.c bsp_bmp.c logic.c para.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group rt-thread-rtos
    ../../src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rt-thread-config
    ../../bsp/: board.c rtconfig.h
  group rt-thread-cpu-config
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group rt-thread-finish-components
    ../../components/finsh/: cmd.c msh.c shell.c
software components: CMSIS:CORE 4.3.0
